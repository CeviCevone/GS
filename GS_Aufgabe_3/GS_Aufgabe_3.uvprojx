# Keil uVision project GS_Aufgabe_3.uvprojx, settings and files
target ITSboard (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ITSboard
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c include: ./Inc;../../stm32cubef4/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../stm32cubef4/Drivers/CMSIS/Include;../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Inc;../../stm32cubef4/Drivers/BSP/STM32F4xx_Nucleo_144;../../stm32cubef4/Utilities/Fonts;../../DisplayWaveshare/Inc;../../ITS_BRD_LIB/Inc;../../ITS_BRD_LIB/Utilities/AddFonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ./: README.md
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../../stm32cubef4/Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/Board
    ../../ITS_BRD_LIB/Src/startup/: system_stm32f4xx.c stm32f4xx_it.c startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Program/User
    ./Src/: main.c errorhandler.c input.c decode.c basic_checks.c output.c
  group Utils
    ../../stm32cubef4/Utilities/Fonts/: font8.c font12.c font16.c font20.c font24.c
    ../../ITS_BRD_LIB/Utilities/AddFonts/: Consolas40.c Consolas60.c Consolas80.c Consolas90.c ConsolasBold40.c ConsolasBold60.c ConsolasBold80.c ConsolasBold90.c CourierNew48.c CourierNewBold40.c CourierNewBold60.c FiraMono40.c FiraMono60.c FiraMono80.c FiraMono90.c FiraMonoMedium40.c FiraMonoMedium60.c FiraMonoMedium80.c FiraMonoMedium90.c fontsFLASH.c
  group LCD
    ../../DisplayWaveshare/Src/: LCD_Driver.c LCD_GUI.c LCD_Touch.c LCD_SPI.c LCD_GPIO.c LCD_TIM.c LCD_Tools.c testsoftware.c LCD_Debug.c LCD_Demos.c
  group ITS_BRD_LIB
    ../../ITS_BRD_LIB/Src/: delay.c error.c init.c keypad.c lcd.c retarget_io.c stdinout_USART.c terminal.c timer.c USART_STM32F4xx.c
  group Program/Header
    ../../ITS_BRD_LIB/Inc/: lcd.h
    ./Inc/: BMP_types.h errorhandler.h input.h MS_basetypes.h decode.h basic_checks.h output.h
  group Program/UserAssembler
    ./: main.s
target ITSboard Assembler (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: ITSboard
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
